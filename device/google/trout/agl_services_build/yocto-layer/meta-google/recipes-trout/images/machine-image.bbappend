IMAGE_INSTALL += "packagegroup-google-agl"
